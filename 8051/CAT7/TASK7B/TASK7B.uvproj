# Keil uVision project TASK7B.uvproj, settings and files
target TASK7B (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: TASK7B +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: TASK7B.c STARTUP.A51

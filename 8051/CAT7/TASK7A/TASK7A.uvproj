# Keil uVision project TASK7A.uvproj, settings and files
target TASK7A (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: TASK7A +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: TASK7A.c STARTUP.A51

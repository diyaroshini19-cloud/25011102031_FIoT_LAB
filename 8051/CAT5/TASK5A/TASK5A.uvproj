# Keil uVision project TASK5A.uvproj, settings and files
target TASK5A (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: TASK5A +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: TASK5A.c STARTUP.A51

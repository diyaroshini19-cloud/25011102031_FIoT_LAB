# Keil uVision project TASK5B.3.uvproj, settings and files
target TASK5B.3 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: TASK5B.3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: TASK5B.3.c STARTUP.A51

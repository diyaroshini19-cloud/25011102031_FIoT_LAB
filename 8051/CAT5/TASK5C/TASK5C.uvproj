# Keil uVision project TASK5C.uvproj, settings and files
target TASK5C (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: TASK5C +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: TASK5C.c STARTUP.A51

# Keil uVision project TASK6B.uvproj, settings and files
target TASK6B (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200)
  output: TASK6B +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Files
    ./: TASK6B.c STARTUP.A51
